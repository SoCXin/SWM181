# IAR project SWM181_StdPeriph_Driver.ewp, settings and files
configuration SWM181 (ARM, debug)
  General.OGChipSelectEditMenu: SWM240x8 Synwit SWM240x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: .\CSL\CMSIS\CoreSupport; .\CSL\CMSIS\DeviceSupport; .\CSL\SWM181_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SWM2400_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: SWM181_StdPeriph_Driver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CSL_StdPD
    ./CSL/SWM181_StdPeriph_Driver/: SWM181_timr.c SWM181_sdadc.c SWM181_can.c SWM181_cache.c SWM181_exti.c SWM181_uart.c SWM181_flash.c SWM181_irqmux.c SWM181_cordic.c SWM181_dma.c SWM181_sleep.c SWM181_adc.c SWM181_pwm.c SWM181_wdt.c SWM181_port.c SWM181_div.c SWM181_cmp.c SWM181_spi.c SWM181_slcd.c SWM181_gpio.c SWM181_i2c.c
  group CSL_CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ./CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM181.s
  group APP
    ./app/: main.c
