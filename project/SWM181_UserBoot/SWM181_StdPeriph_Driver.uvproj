# Keil uVision project SWM181_StdPeriph_Driver.uvproj, settings and files
target SWM181 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SWM181_stdperiph_lib +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM181_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\APP\SWM181_UserBoot.sct
  group APP
    ./app/: main.c
    ./APP/: userboot.c
  group CSL\StdPD
    ./CSL/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cmp.c SWM181_exti.c SWM181_gpio.c SWM181_i2c.c SWM181_pwm.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c SWM181_flash.c SWM181_port.c SWM181_irqmux.c SWM181_spi.c SWM181_sdadc.c SWM181_slcd.c SWM181_dma.c SWM181_can.c SWM181_div.c SWM181_cordic.c SWM181_cache.c SWM181_sleep.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
